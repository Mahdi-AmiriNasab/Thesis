# Keil uVision project balancer.uvprojx, settings and files
target balancer (6210000::V6.21::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: balancer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\..\..\codegen\lib\pso;..\..\..\codegen\includes;..\..\..\equalizer_ert_rtw;..\..\..\Estimations_ert_rtw
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group PSO
    ../../../codegen/lib/pso/: all.c any.c balance_costF.c balance_soc.c calculate_overlap.c db.c diff.c eml_rand_mt19937ar_stateful.c find.c isLocalExtrema.c log_clustering.c minOrMax.c nullAssignment.c pdist2.c pso.c pso_data.c pso_DBSCAN.c pso_emxutil.c pso_initialize.c pso_rtwutil.c pso_terminate.c rand.c rt_nonfinite.c rtGetInf.c rtGetNaN.c sort.c sortIdx.c sortrows.c sortrowsLE.c
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group equalizer
    ../../../equalizer_ert_rtw/: equalizer.c rt_zcfcn.c equalizer_data.c
  group estimation
    ../../../Estimations_ert_rtw/: batteryMeasurementFcn1.c batteryStateFcn1.c cholUpdateFactor_9TQ1AyeS.c const_params.c Estimations.c look2_binlxpw.c qr_284JFiJs.c qr_sQLXF2xn.c rotate_h3nP3JUD.c rt_hypotd_snf.c svd_pFhYsdaI.c trisolve_1hqRQ712.c UTMeanCovSqrt_tkXBHSqd.c UTMeanCovSqrt_y0CmrahB.c xaxpy_jLya3zjW.c xaxpy_JqyUiIN6.c xaxpy_vWVgFQOY.c xdotc_LG9MMAYc.c xgemv_b3RmsEtu.c xgemv_VcPNwKUA.c xgerc_aZmBAV8G.c xgerc_IEYljYzT.c xnrm2_5VDU76G0.c xnrm2_ILvMWxbD.c xnrm2_jKc60KuO.c xnrm2_ka2KfXxR.c xnrm2_Ktlg7eLV.c xrot_qFzRtW7e.c xrotg_clY2b9zV.c xscal_acw0q764.c xscal_HQKDLyyu.c xscal_NhqFnfu9.c xswap_4G8dlkZl.c
software components: CMSIS:CORE 5.1.1
